# IAR project STM32L412k8u.ewp, settings and files
configuration STM32L412k8u (ARM, debug)
  General.OGChipSelectEditMenu: STM32L412KB ST STM32L412KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L412xx; DEBUG; BME280_32BIT_ENABLE; ARM_MATH_CM4; USE_RTC_WATIMER; _DLIB_TIME_USES_64; USE_FULL_LL_DRIVER; USE_HAL_DRIVER
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Inc\WVT; ..\Inc\shared; ..\Libs\BME280_driver; ..\Libs\wa1470\NBFiLib\gost_crypto\crypto; ..\Libs\wa1470\NBFiLib\nbfi; ..\Libs\wa1470\NBFiLib\preambula\preambula; ..\Libs\wa1470\NBFiLib\scheduler\scheduler; ..\Libs\wa1470\NBFiLib\scheduler\scheduler\watimer; ..\Libs\wa1470\NBFiLib\scheduler\scheduler\libmf; ..\Libs\wa1470\NBFiLib\wa1470\wa1470; ..\Inc\NBFiHAL; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ..\Libs\embedded-i2c-sgp40
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32L412k8u.hex
  ILINK.IlinkOutputFile: STM32L412k8u.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l412xx.s
  group Application/User
    ../Src/: adc.c crc.c gpio.c i2c.c iwdg.c main.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c tim.c
  group Application/User/Libs
    ../Libs/BME280_driver/: bme280.c
    ../Libs/wa1470/NBFiLib/gost_crypto/crypto/: magma.c
    ../Libs/wa1470/NBFiLib/preambula/preambula/: preambula.c
    ../Libs/wa1470/NBFiLib/scheduler/scheduler/: scheduler.c
    ../Libs/wa1470/NBFiLib/scheduler/scheduler/watimer/: watimer.c
  group Application/User/Libs/nbfi
    ../Libs/wa1470/NBFiLib/nbfi/: nbfi.c nbfi_config.c nbfi_crc.c nbfi_crypto.c nbfi_mac.c nbfi_rf.c nbfi_transport.c nbfi_transport_misc.c pcode.c zcode.c
  group Application/User/Libs/SGP40
    ../Libs/embedded-i2c-sgp40/: sensirion_common.c sensirion_i2c.c sgp40_i2c.c
    ../Libs/embedded-i2c-sgp40/sample-implementations/STM32L4_series/: sensirion_i2c_hal.c
  group Application/User/Libs/wa1470
    ../Libs/wa1470/NBFiLib/wa1470/wa1470/: wa1470.c wa1470dem.c wa1470mod.c wa1470mod_bpsk_pin.c wa1470rfe.c
  group Application/User/NBFiHAL
    ../Src/NBFiHAL/: nbfi_hal.c radio.c scheduler_hal.c wa1470_hal.c
  group Application/User/shared
    ../Src/shared/: update.c
  group Application/User/WVT
    ../Src/WVT/: cb.c meter.c water7.c WVT_BME280.c WVT_EEPROM.c WVT_SGP40.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_crc.c stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_spi.c stm32l4xx_ll_tim.c stm32l4xx_ll_utils.c
